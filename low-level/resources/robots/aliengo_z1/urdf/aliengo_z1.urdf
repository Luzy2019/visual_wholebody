Commit message: staged

File: low-level/resources/robots/aliengo_z1/urdf/aliengo_z1.urdf (robot description, URDF)
Before this commit: robot aliengo_z1_description, 41 links, 40 joints
Joints:
- joint base_static_joint: origin xyz=0.12 0 0.056 rpy=0 0 0 -> xyz=0.2535 0 0.056 rpy=0 0 0
